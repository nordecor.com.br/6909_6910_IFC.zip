Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-10-22T16:27:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 22 16:27:21 2025 * Host: MichellyManno * Database: C:\Users\miche\AppData\Local\Temp\ba7ad754-d927-4df6-9e87-a49cde397bd0\c6b4219c-6488-4919-9473-3b5926901d8d\ifc * Database version: 5507 * Database creation date: Wed Oct 22 16:27:21 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 22 16:27:21 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 22 16:27:21 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_328254
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 6910, Trilho_Embutir_FINE_6909_6910_Nordecor_IFC:6910:328254
In: Nível 1
Type - Material: Metal - Alumínio - Preto
Type - Cotas - Altura do trilho: 16.3 mm; Largura do trilho: 17 mm
Type - Dados - Data de atualização: 19/10/2025; Versão: 1
Type - Dados de identidade - Código Uniformat: D5020.20; Comentários de tipos: trilho eletrificado, embutir, FINE, 2m, preto, iluminação modular, teto, sistema linear; Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Trilho Eletrificado de embutir FINE com 2m preto; Descrição UniFormat: Luminárias integradas ao edifício; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 ano; IP: 20; Localização: Camboriú-SC / Brasil; Modelo: 6910; Nome do tipo: 6910; Nota-chave: 26 56 33.19; Número MasterFormat: 26 56 33; Número OmniClass: 23.80.70.11.14; Tipo de imagem: Imagem raster: 6910.jpg; Tipo de luminária: Distribuição Linear / Direcional; Título MasterFormat: Spots e Luminárias de Trilho; Título OmniClass: General Luminaries, Directional; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/trilho-eletrificado-de-embutir-fine-2m/
Type - Elétrico - Cargas - Carga aparente - luminária: 0 W
Type - Engenharia elétrica - Fator de potência - Luminária: 1; Voltagem - luminária: 0 V
Type - Estrutural - Peso da luminária: 0
Type - Materiais e acabamentos - Trilho: Metal - Alumínio - Preto
Type - Outros - Categoria: Luminárias; Branco: no; Nome da família: Trilho_Embutir_FINE_6909_6910_Nordecor_IFC; Preto: yes
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Pset_DistributionFlowElementCommon - Reference: 6910; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Área: 0.109794 m2; Comprimento trilho: 2000 mm; Volume: 0.000129711 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Comprimento: 2000 mm; Família: Trilho_Embutir_FINE_6909_6910_Nordecor_IFC: 6910; Família e tipo: Trilho_Embutir_FINE_6909_6910_Nordecor_IFC: 6910; ID de tipo: Trilho_Embutir_FINE_6909_6910_Nordecor_IFC: 6910; Tipo: Trilho_Embutir_FINE_6909_6910_Nordecor_IFC: 6910
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
